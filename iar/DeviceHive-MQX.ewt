<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Int Flash DDRData Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Int Flash DDRData Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>MQX Libraries</name>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\debug\bsp\bsp.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\release\bsp\bsp.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\debug\mfs\mfs.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\release\mfs\mfs.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\debug\psp\psp.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\release\psp\psp.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\debug\rtcs\rtcs.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\MQX_4_1\lib\twrk70f120m.iar\release\rtcs\rtcs.a</name>
    </file>
  </group>
  <group>
    <name>Source</name>
    <group>
      <name>CommonSource</name>
      <file>
        <name>$PROJ_DIR$\..\CommonSource\BuchiTypes.h</name>
      </file>
    </group>
    <group>
      <name>TargetSource</name>
      <group>
        <name>BSL</name>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\BSLlib.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CCriticalSection.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CCriticalSection.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CEvent.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CEvent.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CFileIO.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CThread.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\CThread.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\Logger.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\Logger.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\Namespace.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\NamespaceEND.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\OS.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\BSL\OS.h</name>
        </file>
      </group>
      <group>
        <name>DeviceHive</name>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\Application.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\Application.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\CommandExecutor.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\CommandExecutor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\Connection.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\Connection.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\ConnectionGuard.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\ConnectionGuard.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\DeviceHiveMain.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\DeviceHiveMain.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\GatewayDH.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\GatewayDH.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\HttpClient.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\HttpClient.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\HttpTask.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\HttpTask.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\REST.cpp</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\REST.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\SSLEncryption.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\DeviceHive\SSLEncryption.h</name>
        </file>
      </group>
      <group>
        <name>externals</name>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\externals\cJSON.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\externals\cJSON.h</name>
        </file>
      </group>
      <group>
        <name>Peripherals</name>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\iic.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\iic.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\reset.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\TestPin_think.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\TestPin_think.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\wdog.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\TargetSource\Peripherals\wdog.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\TargetSource\Main.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SSL</name>
    <file>
      <name>$PROJ_DIR$\..\SSL\IDE\IAR-EWARM\Projects\CyaSSL-Lib\Release\Exe\CyaSSL-Lib.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\SSL\IDE\IAR-EWARM\Projects\CyaSSL-Lib\Debug\Exe\CyaSSL-Lib_d.a</name>
    </file>
  </group>
</project>


