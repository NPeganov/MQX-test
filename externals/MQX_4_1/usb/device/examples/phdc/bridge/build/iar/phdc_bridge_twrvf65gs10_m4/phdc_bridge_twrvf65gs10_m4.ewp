# IAR project phdc_bridge_twrvf65gs10_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_M4 Freescale VF6xx_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/bsp; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/psp; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/rtcs; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_m4.bin
  ILINK.IlinkOutputFile: phdc_bridge.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/psp/psp.a; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/rtcs/rtcs.a; ../../../../../../../../lib/twrvf65gs10_m4.iar/debug/usb/usbd.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_m4.iar/release; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/bsp; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/psp; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/rtcs; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_m4.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrvf65gs10_m4.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/psp/psp.a; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/rtcs/rtcs.a; ../../../../../../../../lib/twrvf65gs10_m4.iar/release/usb/usbd.a
  group Source
    ../../../: bridge.c bridge.h ieee11073_nom_codes.h ieee11073_phd_types.h phdc_server.c phdc_server.h usb_descriptor.c usb_descriptor.h
