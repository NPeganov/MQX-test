# Keil uVision project cdc_vnic_frdmk64f.uvproj, settings and files
target cdc_vnic_frdmk64f Int Flash Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: cdc_vnic +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../..;../../../../../../../../lib/frdmk64f.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/frdmk64f.uv4/debug/bsp/Sources;../../../../../../../../lib/frdmk64f.uv4/debug;../../../../../../../../lib/frdmk64f.uv4/debug/bsp;../../../../../../../../lib/frdmk64f.uv4/debug/psp;../../../../../../../../lib/frdmk64f.uv4/debug/rtcs;../../../../../../../../lib/frdmk64f.uv4/debug/usb
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/frdmk64f.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../../lib/frdmk64f.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/frdmk64f.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/frdmk64f.uv4/debug/psp/psp.lib

../../../../../../../../lib/frdmk64f.uv4/debug/psp/psp.lib(linker_symbols.o)

../../../../../../../../lib/frdmk64f.uv4/debug/rtcs/rtcs.lib

../../../../../../../../lib/frdmk64f.uv4/debug/usb/usbd.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: usb_descriptor.c usb_descriptor.h virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h
target cdc_vnic_frdmk64f Int Flash Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: cdc_vnic +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../..;../../../../../../../../lib/frdmk64f.uv4/release/bsp/Generated_Code;../../../../../../../../lib/frdmk64f.uv4/release/bsp/Sources;../../../../../../../../lib/frdmk64f.uv4/release;../../../../../../../../lib/frdmk64f.uv4/release/bsp;../../../../../../../../lib/frdmk64f.uv4/release/psp;../../../../../../../../lib/frdmk64f.uv4/release/rtcs;../../../../../../../../lib/frdmk64f.uv4/release/usb
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../../lib/frdmk64f.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../../lib/frdmk64f.uv4/release/bsp/bsp.lib

../../../../../../../../lib/frdmk64f.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/frdmk64f.uv4/release/psp/psp.lib

../../../../../../../../lib/frdmk64f.uv4/release/psp/psp.lib(linker_symbols.o)

../../../../../../../../lib/frdmk64f.uv4/release/rtcs/rtcs.lib

../../../../../../../../lib/frdmk64f.uv4/release/usb/usbd.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
