# IAR project cdc_vnic_twrk53n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk53n512.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk53n512.iar/debug; ../../../../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../../../../lib/twrk53n512.iar/debug/psp; ../../../../../../../../lib/twrk53n512.iar/debug/rtcs; ../../../../../../../../lib/twrk53n512.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cdc_vnic.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk53n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk53n512.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk53n512.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk53n512.iar/debug/rtcs/rtcs.a; ../../../../../../../../lib/twrk53n512.iar/debug/usb/usbd.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk53n512.iar/release/bsp/Sources; ../../../../../../../../lib/twrk53n512.iar/release; ../../../../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../../../../lib/twrk53n512.iar/release/psp; ../../../../../../../../lib/twrk53n512.iar/release/rtcs; ../../../../../../../../lib/twrk53n512.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk53n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk53n512.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk53n512.iar/release/psp/psp.a; ../../../../../../../../lib/twrk53n512.iar/release/rtcs/rtcs.a; ../../../../../../../../lib/twrk53n512.iar/release/usb/usbd.a
  group Source
    ../../../: usb_descriptor.c usb_descriptor.h virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h
