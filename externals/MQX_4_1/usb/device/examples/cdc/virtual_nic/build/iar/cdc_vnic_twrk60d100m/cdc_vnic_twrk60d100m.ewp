# IAR project cdc_vnic_twrk60d100m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk60d100m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk60d100m.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk60d100m.iar/debug; ../../../../../../../../lib/twrk60d100m.iar/debug/bsp; ../../../../../../../../lib/twrk60d100m.iar/debug/psp; ../../../../../../../../lib/twrk60d100m.iar/debug/rtcs; ../../../../../../../../lib/twrk60d100m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cdc_vnic.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk60d100m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk60d100m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk60d100m.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk60d100m.iar/debug/rtcs/rtcs.a; ../../../../../../../../lib/twrk60d100m.iar/debug/usb/usbd.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk60d100m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk60d100m.iar/release/bsp/Sources; ../../../../../../../../lib/twrk60d100m.iar/release; ../../../../../../../../lib/twrk60d100m.iar/release/bsp; ../../../../../../../../lib/twrk60d100m.iar/release/psp; ../../../../../../../../lib/twrk60d100m.iar/release/rtcs; ../../../../../../../../lib/twrk60d100m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk60d100m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk60d100m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk60d100m.iar/release/psp/psp.a; ../../../../../../../../lib/twrk60d100m.iar/release/rtcs/rtcs.a; ../../../../../../../../lib/twrk60d100m.iar/release/usb/usbd.a
  group Source
    ../../../: usb_descriptor.c usb_descriptor.h virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h
