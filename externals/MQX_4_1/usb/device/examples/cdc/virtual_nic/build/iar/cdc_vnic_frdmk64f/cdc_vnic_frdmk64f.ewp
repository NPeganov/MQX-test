# IAR project cdc_vnic_frdmk64f.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/frdmk64f.iar/debug/bsp/Sources; ../../../../../../../../lib/frdmk64f.iar/debug; ../../../../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../../../../lib/frdmk64f.iar/debug/psp; ../../../../../../../../lib/frdmk64f.iar/debug/rtcs; ../../../../../../../../lib/frdmk64f.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: cdc_vnic.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk64f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/frdmk64f.iar/debug/bsp/bsp.a; ../../../../../../../../lib/frdmk64f.iar/debug/psp/psp.a; ../../../../../../../../lib/frdmk64f.iar/debug/rtcs/rtcs.a; ../../../../../../../../lib/frdmk64f.iar/debug/usb/usbd.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../../../../lib/frdmk64f.iar/release/bsp/Sources; ../../../../../../../../lib/frdmk64f.iar/release; ../../../../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../../../../lib/frdmk64f.iar/release/psp; ../../../../../../../../lib/frdmk64f.iar/release/rtcs; ../../../../../../../../lib/frdmk64f.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/frdmk64f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/frdmk64f.iar/release/bsp/bsp.a; ../../../../../../../../lib/frdmk64f.iar/release/psp/psp.a; ../../../../../../../../lib/frdmk64f.iar/release/rtcs/rtcs.a; ../../../../../../../../lib/frdmk64f.iar/release/usb/usbd.a
  group Source
    ../../../: usb_descriptor.c usb_descriptor.h virtual_nic.c virtual_nic.h virtual_nic_enet.c virtual_nic_enet.h
