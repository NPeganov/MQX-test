# Keil uVision project usbd_kwikstikk40x256.uvproj, settings and files
target usbd_kwikstikk40x256 Debug (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: usbd (library)
  AfterMake: ../../../../../usb/device/build/bat/usbd_kwikstikk40x256.bat ../../../../.. ../../../../../lib/kwikstikk40x256.uv4/debug/usb uv4 & ".copy.bat" "Debug/usbd.lib" "../../../../../lib/kwikstikk40x256.uv4/debug/usb/usbd.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../../source/classes/include;../../../../common/include;../../../source/include;../../../source/include/khci;../../../../host/source/host/khci;../../../source/include/rtos;../../../../../mqx/source/io/adc/kadc;../../../../../mqx/source/io/adc;../../../../../mqx/source/io/cm;../../../../../config/kwikstikk40x256;../../../../../mqx/source/io/dma;../../../../../mqx/source/io/esdhc;../../../../../mqx/source/io/flashx/freescale;../../../../../mqx/source/io/flashx;../../../../../mqx/source/io/can/flexcan;../../../../../mqx/source/io/gpio/kgpio;../../../../../mqx/source/io/gpio;../../../../../mqx/source/io/hmi;../../../../../mqx/source/io/hmi/TSS/shared;../../../../../mqx/source/io/hwtimer;../../../../../mqx/source/io/i2c;../../../../../mqx/source/io/i2c/polled;../../../../../mqx/source/io/i2c/int;../../../../../mqx/source/io/i2s;../../../../../mqx/source/io/i2s/int;../../../../../mqx/source/bsp/kwikstikk40x256;../../../../../config/common;../../../../../mqx/source/include;../../../../../mqx/source/io/enet;../../../../../mqx/source/io/debug;../../../../../mqx/source/io/io_mem;../../../../../mqx/source/io/io_null;../../../../../mqx/source/io/pipe;../../../../../mqx/source/io/lcd;../../../../../mqx/source/io/lpm;../../../../../mqx/source/io/lwadc;../../../../../mqx/source/io/lwgpio;../../../../../mqx/source/io/pcb;../../../../../mqx/source/io/pcb/mqxa;../../../../../mqx/source/io/rtc;../../../../../mqx/source/io/sdcard/sdcard_spi;../../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../../mqx/source/io/sdcard;../../../../../mqx/source/io/serial;../../../../../mqx/source/io/spi;../../../../../mqx/source/io/tfs;../../../../../mqx/source/io/timer;../../../../../mqx/source/io/usb;../../../../../mqx/source/io/usb_dcd;../../../../../mqx/source/io/usb_dcd/polled;../../../../../mqx/source/io/usb_dcd/int;../../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../../mqx/source/psp/cortex_m/cpu;../../../../../mqx/source/psp/cortex_m;../../../../../mqx/source/psp/cortex_m/core/M4;../../../../../mqx/source/tad
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
  group USB Class Drivers/audio
    ../../../source/classes/audio/: usb_audio.c
    ../../../source/classes/include/: usb_audio.h
  group USB Class Drivers/cdc
    ../../../source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    ../../../source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/usb_class
    ../../../source/classes/common/: usb_class.c
    ../../../source/classes/include/: usb_class.h
  group USB Device/include
    ../../../../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_types.h usb_misc_prv.h usb_prv.h
    ../../../source/classes/include/: usb_stack_config.h
    ../../../source/include/: devapi.h dev_main.h dev_cnfg.h
  group USB Class Drivers/framework
    ../../../source/classes/common/: usb_framework.c
    ../../../source/classes/include/: usb_framework.h
  group USB Class Drivers/hid
    ../../../source/classes/hid/: usb_hid.c
    ../../../source/classes/include/: usb_hid.h
  group USB Low Level Driver/khci
    ../../../source/device/khci/: callback_khci.c khci_dev_main.c
    ../../../source/include/khci/: khci_dev_main.h khci_usbprv.h
    ../../../../host/source/host/khci/: khci_prv.h
  group USB Class Drivers/msd
    ../../../source/classes/msd/: usb_msc.c usb_msc_scsi.c
    ../../../source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Device/os
    ../../../source/include/rtos/: mqx_dev.h
  group USB Class Drivers/phdc
    ../../../source/classes/phdc/: usb_phdc.c
    ../../../source/classes/include/: usb_phdc.h
  group USB Device/source
    ../../../source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
target usbd_kwikstikk40x256 Release (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: usbd (library)
  AfterMake: ../../../../../usb/device/build/bat/usbd_kwikstikk40x256.bat ../../../../.. ../../../../../lib/kwikstikk40x256.uv4/release/usb uv4 & ".copy.bat" "Release/usbd.lib" "../../../../../lib/kwikstikk40x256.uv4/release/usb/usbd.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
