# IAR project usbd_vybrid_autoevb_a5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../source/classes/include; ../../../../common/include; ../../../source/include/ehci; ../../../../host/source/host/ehci; ../../../source/include; ../../../source/include/rtos; ../../../../../mqx/source/io/asrc; ../../../../../mqx/source/io/cm; ../../../../../mqx/source/io/cm/vybrid; ../../../../../config/vybrid_autoevb_a5; ../../../../../mqx/source/io/core_mutex; ../../../../../mqx/source/io/dcu4; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/enet/macnet; ../../../../../mqx/source/io/enet/phy; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/esai; ../../../../../mqx/source/io/esai/esai_fifo; ../../../../../mqx/source/io/esai/esai_vport; ../../../../../mqx/source/io/esdhc; ../../../../../mqx/source/io/fbdev; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/ftm; ../../../../../mqx/source/io/ftm/quaddec; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/vybrid_autoevb_a5; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/io/io_expander; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm/vybrid; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/pcb/shmem; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/qspi; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/psp/cortex_a/compiler/iar; ../../../../../mqx/source/psp/cortex_a/cpu; ../../../../../mqx/source/psp/cortex_a; ../../../../../mqx/source/tad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb/device/build/bat/usbd_vybrid_autoevb_a5.bat" "../../../../.." "../../../../../lib/vybrid_autoevb_a5.iar/debug/usb" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../../usb/device/build/bat/usbd_vybrid_autoevb_a5.bat" "../../../../.." "../../../../../lib/vybrid_autoevb_a5.iar/release/usb" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/audio
    ../../../source/classes/audio/: usb_audio.c
    ../../../source/classes/include/: usb_audio.h
  group USB Class Drivers/cdc
    ../../../source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
    ../../../source/classes/include/: usb_cdc.h usb_cdc_pstn.h
  group USB Class Drivers/usb_class
    ../../../source/classes/common/: usb_class.c
    ../../../source/classes/include/: usb_class.h
  group USB Class Drivers/framework
    ../../../source/classes/common/: usb_framework.c
    ../../../source/classes/include/: usb_framework.h
  group USB Class Drivers/hid
    ../../../source/classes/hid/: usb_hid.c
    ../../../source/classes/include/: usb_hid.h
  group USB Class Drivers/msd
    ../../../source/classes/msd/: usb_msc.c usb_msc_scsi.c
    ../../../source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Class Drivers/phdc
    ../../../source/classes/phdc/: usb_phdc.c
    ../../../source/classes/include/: usb_phdc.h
  group USB Device/include
    ../../../../common/include/: usb.h usb_debug.h usb_desc.h usb_error.h usb_misc.h usb_types.h usb_misc_prv.h usb_prv.h
    ../../../source/classes/include/: usb_stack_config.h
    ../../../source/include/: devapi.h dev_main.h dev_cnfg.h
  group USB Device/os
    ../../../source/include/rtos/: mqx_dev.h
  group USB Device/source
    ../../../source/device/: dev_cncl.c dev_ep_deinit.c dev_main.c dev_recv.c dev_send.c dev_shut.c dev_utl.c
  group USB Low Level Driver/ehci
    ../../../source/device/ehci/: callback_ehci.c ehci_dev_main.c
    ../../../source/include/ehci/: ehci_dev_main.h ehci_usbprv.h
    ../../../../host/source/host/ehci/: ehci_prv.h
