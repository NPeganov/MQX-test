# Keil uVision project speaker_host_twrk40d100m.uvproj, settings and files
target speaker_host_twrk40d100m Int Flash Debug (ARM-ADS)
  device: K40DX256M10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: speaker_host +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../..;../../../../../../../../lib/twrk40d100m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk40d100m.uv4/debug/bsp/Sources;../../../../../../../../lib/twrk40d100m.uv4/debug;../../../../../../../../lib/twrk40d100m.uv4/debug/bsp;../../../../../../../../lib/twrk40d100m.uv4/debug/psp;../../../../../../../../lib/twrk40d100m.uv4/debug/mfs;../../../../../../../../lib/twrk40d100m.uv4/debug/shell;../../../../../../../../lib/twrk40d100m.uv4/debug/usb
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../../../lib/twrk40d100m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../../lib/twrk40d100m.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/twrk40d100m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk40d100m.uv4/debug/psp/psp.lib

../../../../../../../../lib/twrk40d100m.uv4/debug/psp/psp.lib(linker_symbols.o)

../../../../../../../../lib/twrk40d100m.uv4/debug/mfs/mfs.lib

../../../../../../../../lib/twrk40d100m.uv4/debug/shell/shell.lib

../../../../../../../../lib/twrk40d100m.uv4/debug/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
target speaker_host_twrk40d100m Int Flash Release (ARM-ADS)
  device: K40DX256M10 Freescale Semiconductor
  cpu: as above
  output: speaker_host +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../..;../../../../../../../../lib/twrk40d100m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk40d100m.uv4/release/bsp/Sources;../../../../../../../../lib/twrk40d100m.uv4/release;../../../../../../../../lib/twrk40d100m.uv4/release/bsp;../../../../../../../../lib/twrk40d100m.uv4/release/psp;../../../../../../../../lib/twrk40d100m.uv4/release/mfs;../../../../../../../../lib/twrk40d100m.uv4/release/shell;../../../../../../../../lib/twrk40d100m.uv4/release/usb
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../../../lib/twrk40d100m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../../lib/twrk40d100m.uv4/release/bsp/bsp.lib

../../../../../../../../lib/twrk40d100m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk40d100m.uv4/release/psp/psp.lib

../../../../../../../../lib/twrk40d100m.uv4/release/psp/psp.lib(linker_symbols.o)

../../../../../../../../lib/twrk40d100m.uv4/release/mfs/mfs.lib

../../../../../../../../lib/twrk40d100m.uv4/release/shell/shell.lib

../../../../../../../../lib/twrk40d100m.uv4/release/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
