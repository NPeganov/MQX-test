# IAR project speaker_host_twrk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk40x256.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk40x256.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk40x256.iar/debug; ../../../../../../../../lib/twrk40x256.iar/debug/bsp; ../../../../../../../../lib/twrk40x256.iar/debug/psp; ../../../../../../../../lib/twrk40x256.iar/debug/mfs; ../../../../../../../../lib/twrk40x256.iar/debug/shell; ../../../../../../../../lib/twrk40x256.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk40x256.srec
  ILINK.IlinkOutputFile: speaker_host.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk40x256.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk40x256.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk40x256.iar/debug/psp/psp.a; ../../../../../../../../lib/twrk40x256.iar/debug/mfs/mfs.a; ../../../../../../../../lib/twrk40x256.iar/debug/shell/shell.a; ../../../../../../../../lib/twrk40x256.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrk40x256.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk40x256.iar/release/bsp/Sources; ../../../../../../../../lib/twrk40x256.iar/release; ../../../../../../../../lib/twrk40x256.iar/release/bsp; ../../../../../../../../lib/twrk40x256.iar/release/psp; ../../../../../../../../lib/twrk40x256.iar/release/mfs; ../../../../../../../../lib/twrk40x256.iar/release/shell; ../../../../../../../../lib/twrk40x256.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk40x256.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrk40x256.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk40x256.iar/release/psp/psp.a; ../../../../../../../../lib/twrk40x256.iar/release/mfs/mfs.a; ../../../../../../../../lib/twrk40x256.iar/release/shell/shell.a; ../../../../../../../../lib/twrk40x256.iar/release/usb/usbh.a
  group Source
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
