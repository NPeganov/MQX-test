# IAR project speaker_host_twrvf65gs10_a5.ewp, settings and files
configuration DDR Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/shell; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_a5.bin
  ILINK.IlinkOutputFile: speaker_host.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/psp/psp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/mfs/mfs.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/shell/shell.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration DDR Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Sources; ../../../../../../../../lib/twrvf65gs10_a5.iar/release; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/psp; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/mfs; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/shell; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/psp/psp.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/mfs/mfs.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/shell/shell.a; ../../../../../../../../lib/twrvf65gs10_a5.iar/release/usb/usbh.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/intram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrvf65gs10_a5.iar/release/bsp/intram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Source
    ../../../: audio_speaker.c audio_speaker.h sh_audio.c sh_audio.h sd_card.h sd_card.c hidkeyboard.h hidkeyboard.c main.c usb_classes.c usb_classes.h wav.c wav.h
