# Keil uVision project web_hvac_twrk70f120m.uvproj, settings and files
target web_hvac_twrk70f120m Int Flash SramData Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: web_hvac +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../..;../../../../../lib/twrk70f120m.uv4/debug/bsp/Generated_Code;../../../../../lib/twrk70f120m.uv4/debug/bsp/Sources;../../../../../lib/twrk70f120m.uv4/debug;../../../../../lib/twrk70f120m.uv4/debug/bsp;../../../../../lib/twrk70f120m.uv4/debug/psp;../../../../../lib/twrk70f120m.uv4/debug/mfs;../../../../../lib/twrk70f120m.uv4/debug/rtcs;../../../../../lib/twrk70f120m.uv4/debug/shell;../../../../../lib/twrk70f120m.uv4/debug/usb
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk70f120m.uv4/debug/bsp/intflash_sramdata.scf
  link misc: ../../../../../lib/twrk70f120m.uv4/debug/bsp/bsp.lib

../../../../../lib/twrk70f120m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../lib/twrk70f120m.uv4/debug/psp/psp.lib

../../../../../lib/twrk70f120m.uv4/debug/psp/psp.lib(linker_symbols.o)

../../../../../lib/twrk70f120m.uv4/debug/mfs/mfs.lib

../../../../../lib/twrk70f120m.uv4/debug/rtcs/rtcs.lib

../../../../../lib/twrk70f120m.uv4/debug/shell/shell.lib

../../../../../lib/twrk70f120m.uv4/debug/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usb_classes.h usb_classes.c
target web_hvac_twrk70f120m Int Flash SramData Release (ARM-ADS)
  device: MK70FX512xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) IROM2(0x10000000-0x1007FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: web_hvac +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../..;../../../../../lib/twrk70f120m.uv4/release/bsp/Generated_Code;../../../../../lib/twrk70f120m.uv4/release/bsp/Sources;../../../../../lib/twrk70f120m.uv4/release;../../../../../lib/twrk70f120m.uv4/release/bsp;../../../../../lib/twrk70f120m.uv4/release/psp;../../../../../lib/twrk70f120m.uv4/release/mfs;../../../../../lib/twrk70f120m.uv4/release/rtcs;../../../../../lib/twrk70f120m.uv4/release/shell;../../../../../lib/twrk70f120m.uv4/release/usb
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk70f120m.uv4/release/bsp/intflash_sramdata.scf
  link misc: ../../../../../lib/twrk70f120m.uv4/release/bsp/bsp.lib

../../../../../lib/twrk70f120m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../lib/twrk70f120m.uv4/release/psp/psp.lib

../../../../../lib/twrk70f120m.uv4/release/psp/psp.lib(linker_symbols.o)

../../../../../lib/twrk70f120m.uv4/release/mfs/mfs.lib

../../../../../lib/twrk70f120m.uv4/release/rtcs/rtcs.lib

../../../../../lib/twrk70f120m.uv4/release/shell/shell.lib

../../../../../lib/twrk70f120m.uv4/release/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
target web_hvac_twrk70f120m Int Flash DDRData Debug (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: web_hvac +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: as above
  c include: as above
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x70000000 size 0x7fffff0
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk70f120m.uv4/debug/bsp/intflash_ddrdata.scf
  link misc: as above
target web_hvac_twrk70f120m Int Flash DDRData Release (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: web_hvac +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x70000000 size 0x7fffff0
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk70f120m.uv4/release/bsp/intflash_ddrdata.scf
  link misc: as above
