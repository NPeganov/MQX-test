# Keil uVision project web_hvac_twrk60d100m.uvproj, settings and files
target web_hvac_twrk60d100m Int Flash Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: web_hvac +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../..;../../../../../lib/twrk60d100m.uv4/debug/bsp/Generated_Code;../../../../../lib/twrk60d100m.uv4/debug/bsp/Sources;../../../../../lib/twrk60d100m.uv4/debug;../../../../../lib/twrk60d100m.uv4/debug/bsp;../../../../../lib/twrk60d100m.uv4/debug/psp;../../../../../lib/twrk60d100m.uv4/debug/mfs;../../../../../lib/twrk60d100m.uv4/debug/rtcs;../../../../../lib/twrk60d100m.uv4/debug/shell;../../../../../lib/twrk60d100m.uv4/debug/usb
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk60d100m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../lib/twrk60d100m.uv4/debug/bsp/bsp.lib

../../../../../lib/twrk60d100m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../lib/twrk60d100m.uv4/debug/psp/psp.lib

../../../../../lib/twrk60d100m.uv4/debug/psp/psp.lib(linker_symbols.o)

../../../../../lib/twrk60d100m.uv4/debug/mfs/mfs.lib

../../../../../lib/twrk60d100m.uv4/debug/rtcs/rtcs.lib

../../../../../lib/twrk60d100m.uv4/debug/shell/shell.lib

../../../../../lib/twrk60d100m.uv4/debug/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usb_classes.h usb_classes.c
target web_hvac_twrk60d100m Int Flash Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: web_hvac +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../..;../../../../../lib/twrk60d100m.uv4/release/bsp/Generated_Code;../../../../../lib/twrk60d100m.uv4/release/bsp/Sources;../../../../../lib/twrk60d100m.uv4/release;../../../../../lib/twrk60d100m.uv4/release/bsp;../../../../../lib/twrk60d100m.uv4/release/psp;../../../../../lib/twrk60d100m.uv4/release/mfs;../../../../../lib/twrk60d100m.uv4/release/rtcs;../../../../../lib/twrk60d100m.uv4/release/shell;../../../../../lib/twrk60d100m.uv4/release/usb
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../lib/twrk60d100m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../lib/twrk60d100m.uv4/release/bsp/bsp.lib

../../../../../lib/twrk60d100m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../lib/twrk60d100m.uv4/release/psp/psp.lib

../../../../../lib/twrk60d100m.uv4/release/psp/psp.lib(linker_symbols.o)

../../../../../lib/twrk60d100m.uv4/release/mfs/mfs.lib

../../../../../lib/twrk60d100m.uv4/release/rtcs/rtcs.lib

../../../../../lib/twrk60d100m.uv4/release/shell/shell.lib

../../../../../lib/twrk60d100m.uv4/release/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
