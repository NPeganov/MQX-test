# IAR project web_hvac_frdmk64f.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/frdmk64f.iar/debug/bsp/Generated_Code; ../../../../../lib/frdmk64f.iar/debug/bsp/Sources; ../../../../../lib/frdmk64f.iar/debug; ../../../../../lib/frdmk64f.iar/debug/bsp; ../../../../../lib/frdmk64f.iar/debug/psp; ../../../../../lib/frdmk64f.iar/debug/mfs; ../../../../../lib/frdmk64f.iar/debug/rtcs; ../../../../../lib/frdmk64f.iar/debug/shell; ../../../../../lib/frdmk64f.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: web_hvac.out
  ILINK.IlinkIcfFile: ../../../../../lib/frdmk64f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/frdmk64f.iar/debug/bsp/bsp.a; ../../../../../lib/frdmk64f.iar/debug/psp/psp.a; ../../../../../lib/frdmk64f.iar/debug/mfs/mfs.a; ../../../../../lib/frdmk64f.iar/debug/rtcs/rtcs.a; ../../../../../lib/frdmk64f.iar/debug/shell/shell.a; ../../../../../lib/frdmk64f.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/frdmk64f.iar/release/bsp/Generated_Code; ../../../../../lib/frdmk64f.iar/release/bsp/Sources; ../../../../../lib/frdmk64f.iar/release; ../../../../../lib/frdmk64f.iar/release/bsp; ../../../../../lib/frdmk64f.iar/release/psp; ../../../../../lib/frdmk64f.iar/release/mfs; ../../../../../lib/frdmk64f.iar/release/rtcs; ../../../../../lib/frdmk64f.iar/release/shell; ../../../../../lib/frdmk64f.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/frdmk64f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/frdmk64f.iar/release/bsp/bsp.a; ../../../../../lib/frdmk64f.iar/release/psp/psp.a; ../../../../../lib/frdmk64f.iar/release/mfs/mfs.a; ../../../../../lib/frdmk64f.iar/release/rtcs/rtcs.a; ../../../../../lib/frdmk64f.iar/release/shell/shell.a; ../../../../../lib/frdmk64f.iar/release/usb/usbh.a
  group Source
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usb_classes.h usb_classes.c
