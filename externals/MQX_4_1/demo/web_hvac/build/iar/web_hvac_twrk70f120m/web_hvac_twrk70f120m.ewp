# IAR project web_hvac_twrk70f120m.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrk70f120m.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk70f120m.iar/debug/bsp/Sources; ../../../../../lib/twrk70f120m.iar/debug; ../../../../../lib/twrk70f120m.iar/debug/bsp; ../../../../../lib/twrk70f120m.iar/debug/psp; ../../../../../lib/twrk70f120m.iar/debug/mfs; ../../../../../lib/twrk70f120m.iar/debug/rtcs; ../../../../../lib/twrk70f120m.iar/debug/shell; ../../../../../lib/twrk70f120m.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkOutputFile: web_hvac.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk70f120m.iar/debug/bsp/intflash_sramdata.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk70f120m.iar/debug/bsp/bsp.a; ../../../../../lib/twrk70f120m.iar/debug/psp/psp.a; ../../../../../lib/twrk70f120m.iar/debug/mfs/mfs.a; ../../../../../lib/twrk70f120m.iar/debug/rtcs/rtcs.a; ../../../../../lib/twrk70f120m.iar/debug/shell/shell.a; ../../../../../lib/twrk70f120m.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../..; ../../../../../lib/twrk70f120m.iar/release/bsp/Generated_Code; ../../../../../lib/twrk70f120m.iar/release/bsp/Sources; ../../../../../lib/twrk70f120m.iar/release; ../../../../../lib/twrk70f120m.iar/release/bsp; ../../../../../lib/twrk70f120m.iar/release/psp; ../../../../../lib/twrk70f120m.iar/release/mfs; ../../../../../lib/twrk70f120m.iar/release/rtcs; ../../../../../lib/twrk70f120m.iar/release/shell; ../../../../../lib/twrk70f120m.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrk70f120m.iar/release/bsp/intflash_sramdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk70f120m.iar/release/bsp/bsp.a; ../../../../../lib/twrk70f120m.iar/release/psp/psp.a; ../../../../../lib/twrk70f120m.iar/release/mfs/mfs.a; ../../../../../lib/twrk70f120m.iar/release/rtcs/rtcs.a; ../../../../../lib/twrk70f120m.iar/release/shell/shell.a; ../../../../../lib/twrk70f120m.iar/release/usb/usbh.a
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ILINK.IlinkIcfFile: ../../../../../lib/twrk70f120m.iar/debug/bsp/intflash_ddrdata.icf
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrk70f120m.iar/release/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: as above
  group Source
    ../../../: command_lists.c hvac.h hvac_io.c hvac_private.h hvac_public.h hvac_shell_commands.c hvac_shell_commands.h hvac_task.c hvac_util.c logging_task.c logging_private.h logging_public.h rtcs.c shell_task.c switch_task.c tasks.c usb_file.c usb_file.h usb_task.c usb_task.h cgi.h cgi_hvac.c cgi_index.c tfs_data.c usb_classes.h usb_classes.c
