# Keil uVision project bsp_kwikstikk40x256.uvproj, settings and files
target bsp_kwikstikk40x256 Debug (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: bsp (library)
  AfterMake: ../../../../mqx/build/bat/bsp_kwikstikk40x256.bat ../../../.. ../../../../lib/kwikstikk40x256.uv4/debug/bsp uv4 & ".copy.bat" "Debug/bsp.lib" "../../../../lib/kwikstikk40x256.uv4/debug/bsp/bsp.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../../config/kwikstikk40x256;../../../source/io/dma;../../../source/io/esdhc;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/can/flexcan;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hmi;../../../source/io/hmi/TSS/shared;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/io/i2s;../../../source/io/i2s/int;../../../source/bsp/kwikstikk40x256;../../../../config/common;../../../source/include;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lcd;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/rtc;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard/sdcard_esdhc;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/io/usb_dcd;../../../source/io/usb_dcd/polled;../../../source/io/usb_dcd/int;../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../source/tad
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
  group Peripheral IO Drivers/adc
    ../../../source/io/adc/kadc/: adc_mk40.c adc_mk40.h
    ../../../source/io/adc/: adc.h adc.c adc_conf.h adc_prv.h
  group Peripheral IO Drivers/adc/kadc
    ../../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Generic IO Drivers/cm
    ../../../source/io/cm/: cm_kinetis.h cm.h cm.c
  group User Config
    ../../../../config/kwikstikk40x256/: user_config.h
  group Peripheral IO Drivers/dma
    ../../../source/io/dma/: edma_kinetis.c dma.c dma.h edma.c edma.h edma_prv.h
  group Peripheral IO Drivers/esdhc
    ../../../source/io/esdhc/: esdhc_mk40.c esdhc.h esdhc.c esdhc_prv.h
  group Peripheral IO Drivers/flashx
    ../../../source/io/flashx/freescale/: flash_mk40.c flash_mk40.h
    ../../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../source/io/flashx/freescale/: flash_ftfl.c flash_ftfl.h flash_ftfl_prv.h
  group Peripheral IO Drivers/flexcan
    ../../../source/io/can/flexcan/: flexcan_mk40.c kflexcan.c kflexcan.h kflexcan_int.c
  group Peripheral IO Drivers/gpio/knxx
    ../../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/gpio
    ../../../source/io/gpio/: io_gpio.h io_gpio.c io_gpio_prv.h
  group Generic IO Drivers/hmi
    ../../../source/io/hmi/: btnled.h btnled.c derivative.h hmi_client.c hmi_client.h hmi_lwgpio_provider.c hmi_lwgpio_provider.h hmi_tss_provider.c hmi_tss_provider.h hmi_uids.h hmi_provider.h
  group Generic IO Drivers/hmi/tss
    ../../../source/io/hmi/TSS/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorGPIO_def.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSI_def.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_SensorTSIL_def.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
  group Peripheral IO Drivers/hwtimer
    ../../../source/io/hwtimer/: hwtimer_lpt.c hwtimer_lpt.h hwtimer_systick.c hwtimer_systick.h hwtimer_pit.c hwtimer_pit.h hwtimer_kinetis.c hwtimer.c hwtimer.h
  group Peripheral IO Drivers/i2c
    ../../../source/io/i2c/: i2c_mk40.c i2c_ki2c.h i2c_ki2c_prv.h i2c.h
    ../../../source/io/i2c/polled/: i2c_pol_ki2c.c
    ../../../source/io/i2c/int/: i2c_int_ki2c_legacy.c
  group Peripheral IO Drivers/i2c/polled
    ../../../source/io/i2c/polled/: i2c_pol_prv.h i2c_pol.c
  group Peripheral IO Drivers/i2c/int
    ../../../source/io/i2c/int/: i2c_int_prv.h i2c_int.c
  group Peripheral IO Drivers/i2s
    ../../../source/io/i2s/: i2s_mk40.c i2s_audio.h i2s_ki2s.h i2s_ki2s_prv.h i2s.h
    ../../../source/io/i2s/int/: i2s_int_prv.h i2s_int.c
  group Peripheral IO Drivers/i2s/int
    ../../../source/io/i2s/int/: i2s_int_ki2s.c
  group BSP Files
    ../../../source/bsp/kwikstikk40x256/: bsp_cm.h bsp_cm.c init_adc.c init_lwadc.c init_esdhc.c init_flashx.c init_gpio.c init_hw.c TSS_SystemSetup.h init_hmi.c init_i2c.c init_i2s.c init_iodebug.c init_lpm.c init_lpm.h init_sci.c init_sdcard.c init_spi.c init_usb.c init_usb_dcd.c init_dma.c bsp.h bsp_prv.h bsp_rev.h init_bsp.c mqx_init.c mqx_main.c PE_LDD.h PE_Types.h kwikstik-k40x256.h vectors.c
    ../../../../config/common/: small_ram_config.h smallest_config.h maximum_config.h verif_enabled_config.h
    ../../../source/include/: mqx.h
    ../../../source/io/enet/: ethernet.h enet.h enet_wifi.h
  group Generic IO Drivers/debug
    ../../../source/io/debug/: iodebug.h iodebug_prv.h iodebug.c iodebug_asm.S
  group Generic IO Drivers/io_mem
    ../../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../../../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Peripheral IO Drivers/enet
    ../../../source/io/lcd/: Fonts_LCD.c Fonts_LCD.h slcd_kwikstik-k40x256.c slcd_kwikstik-k40x256.h PounceTypes_v2.h
  group Generic IO Drivers/lpm
    ../../../source/io/lpm/: lpm_kinetis.h lpm_mc.c lpm.h lpm_prv.h lpm.c
  group Peripheral IO Drivers/lwadc/kadc
    ../../../source/io/lwadc/: lwadc_kadc.c lwadc_kadc.h lwadc_kadc_prv.h
  group Peripheral IO Drivers/lwadc
    ../../../source/io/lwadc/: lwadc.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/lwgpio
    ../../../source/io/lwgpio/: lwgpio.h lwgpio.c
  group Generic IO Drivers/pcb
    ../../../source/io/pcb/: io_pcb2.c io_pcb.c io_pcb.h iop_inst.c iopcbprv.h
    ../../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Peripheral IO Drivers/rtc
    ../../../source/io/rtc/: krtc.h krtc.c rtc.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../../../source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.c sdcard_esdhc.h
  group Peripheral IO Drivers/sdcard
    ../../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/serial
    ../../../source/io/serial/: serl_mk40.c serl_kuart.h io_sinit.c serial.h serinprv.h serplprv.h
  group Peripheral IO Drivers/serial/int
    ../../../source/io/serial/int/: serl_int_kuart.c serl_int.c
  group Peripheral IO Drivers/serial/polled
    ../../../source/io/serial/polled/: serl_pol_kuart.c serl_pol.c
  group Peripheral IO Drivers/serial/dma
    ../../../source/io/serial/dma/: serl_dma_kuart.c
  group Peripheral IO Drivers/spi
    ../../../source/io/spi/: spi_mk40.c spi_dspi_dma.h spi_dspi_dma.c spi_dspi_dma_prv.h spi_dspi_common.h spi_dspi_common.c spi.h spi.c spi_prv.h spi_dspi.h spi_dspi.c spi_dspi_prv.h
  group Generic IO Drivers/tfs
    ../../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Peripheral IO Drivers/timer
    ../../../source/io/timer/: timer_qpit.c timer_kinetis.c timer_qpit.h qpit.h
  group Peripheral IO Drivers/usb
    ../../../source/io/usb/: usb_mk40.c usb_mk40_device.c if_host_ehci.h if_host_khci.h if_dev_ehci.h if_dev_khci.h usb_bsp.h usb_install.c
  group Peripheral IO Drivers/usb_dcc
    ../../../source/io/usb_dcd/: usb_dcd_mk40.c usb_dcd_kn.h usb_dcd_kn_prv.h usb_dcd.h
  group Peripheral IO Drivers/usb_dcc/polled
    ../../../source/io/usb_dcd/polled/: usb_dcd_pol_kn.c usb_dcd_pol_prv.h usb_dcd_pol.c
  group Peripheral IO Drivers/usb_dcc/int
    ../../../source/io/usb_dcd/int/: usb_dcd_int_kn.c usb_dcd_int_prv.h usb_dcd_int.c
target bsp_kwikstikk40x256 Release (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: bsp (library)
  AfterMake: ../../../../mqx/build/bat/bsp_kwikstikk40x256.bat ../../../.. ../../../../lib/kwikstikk40x256.uv4/release/bsp uv4 & ".copy.bat" "Release/bsp.lib" "../../../../lib/kwikstikk40x256.uv4/release/bsp/bsp.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
