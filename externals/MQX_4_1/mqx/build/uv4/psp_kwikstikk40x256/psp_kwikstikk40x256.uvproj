# Keil uVision project psp_kwikstikk40x256.uvproj, settings and files
target psp_kwikstikk40x256 Debug (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: psp (library)
  AfterMake: ../../../../mqx/build/bat/psp_kwikstikk40x256.bat ../../../.. ../../../../lib/kwikstikk40x256.uv4/debug/psp uv4 & ".copy.bat" "Debug/psp.lib" "../../../../lib/kwikstikk40x256.uv4/debug/psp/psp.lib"
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK=1, _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../../config/kwikstikk40x256;../../../../config/common;../../../source/include;../../../source/tad;../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../source/io/dma;../../../source/io/esdhc;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/can/flexcan;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hmi;../../../source/io/hmi/TSS/shared;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/io/i2s;../../../source/io/i2s/int;../../../source/bsp/kwikstikk40x256;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lcd;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/rtc;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard/sdcard_esdhc;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/io/usb_dcd;../../../source/io/usb_dcd/polled;../../../source/io/usb_dcd/int
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
  group PSP Cortex/compiler
    ../../../source/psp/cortex_m/compiler/rv_uv4/: asm_mac.h comp.h comp.c linker_symbols.S
  group PSP Cortex
    ../../../source/psp/cortex_m/cpu/: MK40DZ10.h kinetis_fcan.h
    ../../../source/psp/cortex_m/: kinetis_mpu.h kinetis_mpu.c int_gkis.c int_inst.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c psp.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h psp_cpudef.h cortex.h cortex.c nvic.c nvic.h kinetis.h
    ../../../source/psp/cortex_m/core/M4/: boot.S dispatch.S support.S
  group User Config
    ../../../../config/kwikstikk40x256/: user_config.h
    ../../../../config/common/: small_ram_config.h
  group PSP Generic/kernel
    ../../../source/kernel/: event.c ipc.c idletask.c inittask.c int.c lwsem.c mem.c mqx.c sched.c task.c time.c taskq.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c name.c partition.c queue.c sem.c timer.c watchdog.c
  group PSP Generic/fio
    ../../../source/fio/: io_clre.c io_dopr.c io_fclos.c io_feof.c io_ferr.c io_fflsh.c io_fgetc.c io_fgetl.c io_fgets.c io_fopen.c io_fp.c io_fprt.c io_fputc.c io_fputs.c io_fscan.c io_fseek.c io_fstat.c io_ftell.c io_fung.c io_ioctl.c io_misc.c io_pntf.c io_read.c io_scanf.c io_scanl.c io_spr.c io_sscan.c io_util.c io_vpr.c io_write.c
  group PSP Generic/include
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h fio.h fio_prv.h fpio_prv.h charq.h io.h ioctl.h io_prv.h io_rev.h ipc.h ipcrtprv.h ipc_pcb.h ipc_pcbv.h ipc_prv.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cnfg.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h posix.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h unicode.h
  group PSP Generic/io
    ../../../source/io/: io_init.c io_inst.c io_instx.c io_ghand.c io_shand.c io_uinst.c
  group PSP Generic/string
    ../../../source/string/: strnlen.c str_utos.c unicode.c
  group PSP Generic/tad
    ../../../source/tad/: tad.c tad.h
target psp_kwikstikk40x256 Release (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: psp (library)
  AfterMake: ../../../../mqx/build/bat/psp_kwikstikk40x256.bat ../../../.. ../../../../lib/kwikstikk40x256.uv4/release/psp uv4 & ".copy.bat" "Release/psp.lib" "../../../../lib/kwikstikk40x256.uv4/release/psp/psp.lib"
  c flags: Optim=4 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
