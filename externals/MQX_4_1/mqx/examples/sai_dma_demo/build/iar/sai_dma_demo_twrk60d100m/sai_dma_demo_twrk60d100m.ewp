# IAR project sai_dma_demo_twrk60d100m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk60d100m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk60d100m.iar/debug/bsp/Sources; ../../../../../../lib/twrk60d100m.iar/debug; ../../../../../../lib/twrk60d100m.iar/debug/bsp; ../../../../../../lib/twrk60d100m.iar/debug/psp; ../../../../../../lib/twrk60d100m.iar/debug/mfs; ../../../../../../lib/twrk60d100m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: sai_dma_demo.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk60d100m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk60d100m.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk60d100m.iar/debug/psp/psp.a; ../../../../../../lib/twrk60d100m.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk60d100m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk60d100m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk60d100m.iar/release/bsp/Sources; ../../../../../../lib/twrk60d100m.iar/release; ../../../../../../lib/twrk60d100m.iar/release/bsp; ../../../../../../lib/twrk60d100m.iar/release/psp; ../../../../../../lib/twrk60d100m.iar/release/mfs; ../../../../../../lib/twrk60d100m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk60d100m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk60d100m.iar/release/bsp/bsp.a; ../../../../../../lib/twrk60d100m.iar/release/psp/psp.a; ../../../../../../lib/twrk60d100m.iar/release/mfs/mfs.a; ../../../../../../lib/twrk60d100m.iar/release/shell/shell.a
  group Source
    ../../../: log_messages.c log_messages.h main.c main.h sgtl5000.c sgtl5000.h sh_audio.c sh_audio.h wav.c wav.h
