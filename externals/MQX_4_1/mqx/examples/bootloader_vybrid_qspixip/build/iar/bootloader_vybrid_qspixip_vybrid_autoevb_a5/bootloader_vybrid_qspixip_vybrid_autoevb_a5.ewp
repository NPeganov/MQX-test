# IAR project bootloader_vybrid_qspixip_vybrid_autoevb_a5.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../md5; ../../../../qspi; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp/Sources; ../../../../../../lib/vybrid_autoevb_a5.iar/debug; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/psp; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/mfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: vybrid_autoevb_a5.bin
  ILINK.IlinkOutputFile: bootloader_vybrid_qspixip.out
  ILINK.IlinkIcfFile: ../../../sram_iar_a5.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp/bsp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/psp/psp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/mfs/mfs.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../..; ../../../md5; ../../../../qspi; ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp/Sources; ../../../../../../lib/vybrid_autoevb_a5.iar/release; ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp; ../../../../../../lib/vybrid_autoevb_a5.iar/release/psp; ../../../../../../lib/vybrid_autoevb_a5.iar/release/mfs
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp/bsp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/release/psp/psp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/release/mfs/mfs.a
  group Source
    ../../../: boot.c quadspi_boot.c quadspi_boot.h iniparser.c iniparser.h
    ../../../../qspi/: qspi_memory.c qspi_memory.h
  group Source/md5
    ../../../md5/: md5.c md5.h
