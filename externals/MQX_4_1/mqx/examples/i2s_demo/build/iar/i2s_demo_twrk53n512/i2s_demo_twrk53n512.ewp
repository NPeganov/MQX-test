# IAR project i2s_demo_twrk53n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk53n512.iar/debug/bsp/Sources; ../../../../../../lib/twrk53n512.iar/debug; ../../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../../lib/twrk53n512.iar/debug/psp; ../../../../../../lib/twrk53n512.iar/debug/mfs; ../../../../../../lib/twrk53n512.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: i2s_demo.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk53n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk53n512.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk53n512.iar/debug/psp/psp.a; ../../../../../../lib/twrk53n512.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk53n512.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk53n512.iar/release/bsp/Sources; ../../../../../../lib/twrk53n512.iar/release; ../../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../../lib/twrk53n512.iar/release/psp; ../../../../../../lib/twrk53n512.iar/release/mfs; ../../../../../../lib/twrk53n512.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk53n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk53n512.iar/release/bsp/bsp.a; ../../../../../../lib/twrk53n512.iar/release/psp/psp.a; ../../../../../../lib/twrk53n512.iar/release/mfs/mfs.a; ../../../../../../lib/twrk53n512.iar/release/shell/shell.a
  group Source
    ../../../: log_messages.c log_messages.h main.c main.h sgtl5000.c sgtl5000.h sh_audio.c sh_audio.h wav.c wav.h
