# Keil uVision project shell_twrk60f120m.uvproj, settings and files
target shell_twrk60f120m Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: shell (library)
  AfterMake: ../../../../shell/build/bat/shell_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/shell uv4 & ".copy.bat" "Debug/shell.lib" "../../../../lib/twrk60f120m.uv4/debug/shell/shell.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/twrk60f120m;../../../../mqx/source/io/dma;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/enet;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/twrk60f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/nandflash/nfc;../../../../mqx/source/io/nandflash;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tchres;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad;../../../../mfs/source/include;../../../../rtcs/source/include;../../../../usb/device/source/classes/include;../../../../usb/common/include;../../../../usb/device/source/include/ehci;../../../../usb/host/source/host/ehci;../../../../usb/device/source/include;../../../../usb/device/source/include/khci;../../../../usb/host/source/host/khci;../../../../usb/device/source/include/rtos;../../../../usb/host/source/classes/audio;../../../../usb/host/source/classes/cdc;../../../../usb/host/source/classes/hid;../../../../usb/host/source/classes/hub;../../../../usb/host/source/include;../../../../usb/host/source/classes/msd;../../../../usb/host/source/classes/msd/mfs;../../../../usb/host/source/rtos/mqx;../../../../usb/host/source/classes/phdc;../../../../usb/host/source/classes/printer
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group Shell Source/mfs
    ../../../source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../source/include/: sh_mfs.h
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/rtcs
    ../../../source/rtcs/: sh_arpdisp.c sh_clock.c sh_echod.c sh_eds.c sh_enet.c sh_exec.c sh_ftpc.c sh_ftpd.c sh_gate.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_load.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftp.c sh_tftpd.c sh_tnet.c sh_tnetd.c
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
target shell_twrk60f120m Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: shell (library)
  AfterMake: ../../../../shell/build/bat/shell_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/shell uv4 & ".copy.bat" "Release/shell.lib" "../../../../lib/twrk60f120m.uv4/release/shell/shell.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
