# IAR project rtcs_shell_twrk60n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk60n512.iar/debug/bsp/Sources; ../../../../../../lib/twrk60n512.iar/debug; ../../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../../lib/twrk60n512.iar/debug/mfs; ../../../../../../lib/twrk60n512.iar/debug/rtcs; ../../../../../../lib/twrk60n512.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: rtcs_shell.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk60n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk60n512.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk60n512.iar/debug/psp/psp.a; ../../../../../../lib/twrk60n512.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk60n512.iar/debug/rtcs/rtcs.a; ../../../../../../lib/twrk60n512.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk60n512.iar/release/bsp/Sources; ../../../../../../lib/twrk60n512.iar/release; ../../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../../lib/twrk60n512.iar/release/psp; ../../../../../../lib/twrk60n512.iar/release/mfs; ../../../../../../lib/twrk60n512.iar/release/rtcs; ../../../../../../lib/twrk60n512.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk60n512.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk60n512.iar/release/bsp/bsp.a; ../../../../../../lib/twrk60n512.iar/release/psp/psp.a; ../../../../../../lib/twrk60n512.iar/release/mfs/mfs.a; ../../../../../../lib/twrk60n512.iar/release/rtcs/rtcs.a; ../../../../../../lib/twrk60n512.iar/release/shell/shell.a
  group Source
    ../../../: config.h demo.c demo_cmd.c _README.txt
