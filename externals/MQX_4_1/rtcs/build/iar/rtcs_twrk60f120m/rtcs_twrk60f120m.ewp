# IAR project rtcs_twrk60f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../source/include; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/io/cm; ../../../../config/twrk60f120m; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/twrk60f120m; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/tad; ../../../../mfs/source/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../rtcs/build/bat/rtcs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/rtcs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../rtcs/build/bat/rtcs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/rtcs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group RTCS Source/apps
    ../../../source/apps/: binfile.c coff.c dhcpsrv.c echosrv.c eds.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_supp.c httpsrv_task.c loadtb.c loadtc.c loadts.c resolver.c rtcsload.c rtcs_base64.c rtcs_smtp.c sntp.c sockio.c srec32.c srecord.c telnet.c telnetio.c telnsrv.c tftp.c tftpacc.c tftpsrv.c tftputil.c dnscln.c
  group RTCS Source/if
    ../../../source/if/: arpcmd.c dnshosts.c dnsinit.c dnsutil.c ghbname.c ifadd.c ifbootp.c ifdhcp.c ifdns.c ifppp.c ifrem.c ifstat.c iftraps.c iftunnel.c inet.c ipcfg.c iwcfg.c ping.c rtcs.c rtcscmd.c rtcsdela.c rtcsglob.c rtcshost.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sdgram.c sockutil.c soigmp.c soip.c solink.c sosel.c sosock.c sotcp.c soudp.c sstream.c getaddrinfo.c getnameinfo.c inet_ntop.c inet_pton.c ipcfg6.c ping6.c
  group RTCS Source/media
    ../../../source/media/: arp.c arpinit.c ipcp.c ipcpfsm.c ip-e.c proxyarp.c
  group RTCS Source/nat
    ../../../source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group RTCS Source/os
    ../../../source/os/mqx25x/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    ../../../source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source/snmp
    ../../../source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    ../../../source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ipif_add.c ipif_rem.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c checksum6.c
  group RTCS Include
    ../../../source/include/: arp.h arp_prv.h arpif.h asn1.h bootp.h ccp.h chap.h checksum.h dhcp.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dns.h dnscln.h fcs16.h ftpc.h ftpsrv.h ftpsrv_msg.h ftpsrv_prv.h httpsrv.h httpsrv_prv.h httpsrv_supp.h icmp.h icmp_prv.h igmp.h ip.h ip_prv.h ip_if.h ipcfg.h ipcfg_prv.h iwcfg.h ipcp.h ipc_udp.h ipc_udp_prv.h ip-e.h ipradix.h iptunnel.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h pap.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h rip_prv.h route.h rtcs.h rtcs_sock.h rtcs_err.h rtcs_stats.h rtcs_if.h rtcs_base64.h rtcs_in.h rtcs_prv.h rtcs_smtp.h rtcs25x.h rtcscfg.h rtcslog.h rtcspcb.h rtcsrtos.h rtcstime.h rtcsvers.h snmp.h snmpcfg.h socket.h tcp.h tcp_prv.h tcpip.h telnet.h tftp.h ticker.h udp.h udp_prv.h icmp6.h icmp6_prv.h ip6.h ip6_if.h ip6_prv.h ip6_trace.h nd6.h mld.h addrinfo.h
