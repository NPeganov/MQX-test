# Keil uVision project rtcs_kwikstikk40x256.uvproj, settings and files
target rtcs_kwikstikk40x256 Debug (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: rtcs (library)
  AfterMake: ../../../../rtcs/build/bat/rtcs_kwikstikk40x256.bat ../../../.. ../../../../lib/kwikstikk40x256.uv4/debug/rtcs uv4 & ".copy.bat" "Debug/rtcs.lib" "../../../../lib/kwikstikk40x256.uv4/debug/rtcs/rtcs.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/kwikstikk40x256;../../../../mqx/source/io/dma;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hmi;../../../../mqx/source/io/hmi/TSS/shared;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/io/i2s;../../../../mqx/source/io/i2s/int;../../../../mqx/source/bsp/kwikstikk40x256;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lcd;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad;../../../../mfs/source/include
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
  group RTCS Source/apps
    ../../../source/apps/: binfile.c coff.c dhcpsrv.c echosrv.c eds.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_supp.c httpsrv_task.c loadtb.c loadtc.c loadts.c resolver.c rtcsload.c rtcs_base64.c rtcs_smtp.c sntp.c sockio.c srec32.c srecord.c telnet.c telnetio.c telnsrv.c tftp.c tftpacc.c tftpsrv.c tftputil.c dnscln.c
  group RTCS Source/if
    ../../../source/if/: arpcmd.c dnshosts.c dnsinit.c dnsutil.c ghbname.c ifadd.c ifbootp.c ifdhcp.c ifdns.c ifppp.c ifrem.c ifstat.c iftraps.c iftunnel.c inet.c ipcfg.c iwcfg.c ping.c rtcs.c rtcscmd.c rtcsdela.c rtcsglob.c rtcshost.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sdgram.c sockutil.c soigmp.c soip.c solink.c sosel.c sosock.c sotcp.c soudp.c sstream.c getaddrinfo.c getnameinfo.c inet_ntop.c inet_pton.c ipcfg6.c ping6.c
  group RTCS Include
    ../../../source/include/: arp.h arp_prv.h arpif.h asn1.h bootp.h ccp.h chap.h checksum.h dhcp.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dns.h dnscln.h fcs16.h ftpc.h ftpsrv.h ftpsrv_msg.h ftpsrv_prv.h httpsrv.h httpsrv_prv.h httpsrv_supp.h icmp.h icmp_prv.h igmp.h ip.h ip_prv.h ip_if.h ipcfg.h ipcfg_prv.h iwcfg.h ipcp.h ipc_udp.h ipc_udp_prv.h ip-e.h ipradix.h iptunnel.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h pap.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h rip_prv.h route.h rtcs.h rtcs_sock.h rtcs_err.h rtcs_stats.h rtcs_if.h rtcs_base64.h rtcs_in.h rtcs_prv.h rtcs_smtp.h rtcs25x.h rtcscfg.h rtcslog.h rtcspcb.h rtcsrtos.h rtcstime.h rtcsvers.h snmp.h snmpcfg.h socket.h tcp.h tcp_prv.h tcpip.h telnet.h tftp.h ticker.h udp.h udp_prv.h icmp6.h icmp6_prv.h ip6.h ip6_if.h ip6_prv.h ip6_trace.h nd6.h mld.h addrinfo.h
  group RTCS Source/media
    ../../../source/media/: arp.c arpinit.c ipcp.c ipcpfsm.c ip-e.c proxyarp.c
  group RTCS Source/nat
    ../../../source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group RTCS Source/os
    ../../../source/os/mqx25x/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    ../../../source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group RTCS Source/snmp
    ../../../source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    ../../../source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ipif_add.c ipif_rem.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c checksum6.c
target rtcs_kwikstikk40x256 Release (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: rtcs (library)
  AfterMake: ../../../../rtcs/build/bat/rtcs_kwikstikk40x256.bat ../../../.. ../../../../lib/kwikstikk40x256.uv4/release/rtcs uv4 & ".copy.bat" "Release/rtcs.lib" "../../../../lib/kwikstikk40x256.uv4/release/rtcs/rtcs.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\kwikstikk40x256.uv4\mqx\intflash.scf
