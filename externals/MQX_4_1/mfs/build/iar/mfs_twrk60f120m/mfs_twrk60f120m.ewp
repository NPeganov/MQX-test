# IAR project mfs_twrk60f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../source/include; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/io/cm; ../../../../config/twrk60f120m; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/twrk60f120m; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/tad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../mfs/build/bat/mfs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/mfs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../mfs/build/bat/mfs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/mfs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group MFS Include
    ../../../source/include/: mfs_cnfg.h mfs_prv.h mfs_rev.h mfs.h part_mgr.h
  group MFS Source
    ../../../source/generic/: dir_read.c mfs_attribute.c mfs_cluster.c mfs_create.c mfs_data_sector.c mfs_delete.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_format.c mfs_handle.c mfs_init.c mfs_lfn.c mfs_misc.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_valdev.c mfs_write.c part_mgr.c
