# IAR project mfs_vybrid_autoevb_a5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../source/include; ../../../../mqx/source/io/asrc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/cm/vybrid; ../../../../config/vybrid_autoevb_a5; ../../../../mqx/source/io/core_mutex; ../../../../mqx/source/io/dcu4; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/esai; ../../../../mqx/source/io/esai/esai_fifo; ../../../../mqx/source/io/esai/esai_vport; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/fbdev; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/ftm; ../../../../mqx/source/io/ftm/quaddec; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/vybrid_autoevb_a5; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/io/io_expander; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm/vybrid; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/pcb/shmem; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/qspi; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/usb; ../../../../mqx/source/psp/cortex_a/compiler/iar; ../../../../mqx/source/psp/cortex_a/cpu; ../../../../mqx/source/psp/cortex_a; ../../../../mqx/source/tad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  postbuild: "../../../../mfs/build/bat/mfs_vybrid_autoevb_a5.bat" "../../../.." "../../../../lib/vybrid_autoevb_a5.iar/debug/mfs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../mfs/build/bat/mfs_vybrid_autoevb_a5.bat" "../../../.." "../../../../lib/vybrid_autoevb_a5.iar/release/mfs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group MFS Include
    ../../../source/include/: mfs_cnfg.h mfs_prv.h mfs_rev.h mfs.h part_mgr.h
  group MFS Source
    ../../../source/generic/: dir_read.c mfs_attribute.c mfs_cluster.c mfs_create.c mfs_data_sector.c mfs_delete.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_format.c mfs_handle.c mfs_init.c mfs_lfn.c mfs_misc.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_valdev.c mfs_write.c part_mgr.c
