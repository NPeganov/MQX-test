# Keil uVision project mfs_usb_twrk21d50m.uvproj, settings and files
target mfs_usb_twrk21d50m Int Flash Debug (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: mfs_usb +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../..;../../../../../../lib/twrk21d50m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk21d50m.uv4/debug/bsp/Sources;../../../../../../lib/twrk21d50m.uv4/debug;../../../../../../lib/twrk21d50m.uv4/debug/bsp;../../../../../../lib/twrk21d50m.uv4/debug/psp;../../../../../../lib/twrk21d50m.uv4/debug/mfs;../../../../../../lib/twrk21d50m.uv4/debug/shell;../../../../../../lib/twrk21d50m.uv4/debug/usb
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x08000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../lib/twrk21d50m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk21d50m.uv4/debug/bsp/bsp.lib

../../../../../../lib/twrk21d50m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../lib/twrk21d50m.uv4/debug/psp/psp.lib

../../../../../../lib/twrk21d50m.uv4/debug/psp/psp.lib(linker_symbols.o)

../../../../../../lib/twrk21d50m.uv4/debug/mfs/mfs.lib

../../../../../../lib/twrk21d50m.uv4/debug/shell/shell.lib

../../../../../../lib/twrk21d50m.uv4/debug/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: usb_task.h usb_task.c usb_file.h usb_file.c usb_classes.c usb_classes.h tasks.c shell_task.c mfs_usb.h command_lists.c
target mfs_usb_twrk21d50m Int Flash Release (ARM-ADS)
  device: MK20DN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: mfs_usb +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../..;../../../../../../lib/twrk21d50m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk21d50m.uv4/release/bsp/Sources;../../../../../../lib/twrk21d50m.uv4/release;../../../../../../lib/twrk21d50m.uv4/release/bsp;../../../../../../lib/twrk21d50m.uv4/release/psp;../../../../../../lib/twrk21d50m.uv4/release/mfs;../../../../../../lib/twrk21d50m.uv4/release/shell;../../../../../../lib/twrk21d50m.uv4/release/usb
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x08000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ../../../../../../lib/twrk21d50m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk21d50m.uv4/release/bsp/bsp.lib

../../../../../../lib/twrk21d50m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../lib/twrk21d50m.uv4/release/psp/psp.lib

../../../../../../lib/twrk21d50m.uv4/release/psp/psp.lib(linker_symbols.o)

../../../../../../lib/twrk21d50m.uv4/release/mfs/mfs.lib

../../../../../../lib/twrk21d50m.uv4/release/shell/shell.lib

../../../../../../lib/twrk21d50m.uv4/release/usb/usbh.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
