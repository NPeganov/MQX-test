# IAR project mfs_usb_vybrid_autoevb_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_M4 Freescale VF6xx_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/bsp/Generated_Code; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/bsp/Sources; ../../../../../../lib/vybrid_autoevb_m4.iar/debug; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/bsp; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/psp; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/mfs; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/shell; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/usb
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: vybrid_autoevb_m4.bin
  ILINK.IlinkOutputFile: mfs_usb.out
  ILINK.IlinkIcfFile: ../../../../../../lib/vybrid_autoevb_m4.iar/debug/bsp/ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/vybrid_autoevb_m4.iar/debug/bsp/bsp.a; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/psp/psp.a; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/mfs/mfs.a; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/shell/shell.a; ../../../../../../lib/vybrid_autoevb_m4.iar/debug/usb/usbh.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/vybrid_autoevb_m4.iar/release/bsp/Generated_Code; ../../../../../../lib/vybrid_autoevb_m4.iar/release/bsp/Sources; ../../../../../../lib/vybrid_autoevb_m4.iar/release; ../../../../../../lib/vybrid_autoevb_m4.iar/release/bsp; ../../../../../../lib/vybrid_autoevb_m4.iar/release/psp; ../../../../../../lib/vybrid_autoevb_m4.iar/release/mfs; ../../../../../../lib/vybrid_autoevb_m4.iar/release/shell; ../../../../../../lib/vybrid_autoevb_m4.iar/release/usb
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/vybrid_autoevb_m4.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/vybrid_autoevb_m4.iar/release/bsp/bsp.a; ../../../../../../lib/vybrid_autoevb_m4.iar/release/psp/psp.a; ../../../../../../lib/vybrid_autoevb_m4.iar/release/mfs/mfs.a; ../../../../../../lib/vybrid_autoevb_m4.iar/release/shell/shell.a; ../../../../../../lib/vybrid_autoevb_m4.iar/release/usb/usbh.a
  group Source
    ../../../: usb_task.h usb_task.c usb_file.h usb_file.c usb_classes.c usb_classes.h tasks.c shell_task.c mfs_usb.h command_lists.c
