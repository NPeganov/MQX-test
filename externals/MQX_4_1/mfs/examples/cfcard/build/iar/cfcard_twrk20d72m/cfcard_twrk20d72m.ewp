# IAR project cfcard_twrk20d72m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX256Zxxx10 Freescale MK20DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk20d72m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk20d72m.iar/debug/bsp/Sources; ../../../../../../lib/twrk20d72m.iar/debug; ../../../../../../lib/twrk20d72m.iar/debug/bsp; ../../../../../../lib/twrk20d72m.iar/debug/psp; ../../../../../../lib/twrk20d72m.iar/debug/mfs; ../../../../../../lib/twrk20d72m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk20d72m.srec
  ILINK.IlinkOutputFile: cfcard.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk20d72m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk20d72m.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk20d72m.iar/debug/psp/psp.a; ../../../../../../lib/twrk20d72m.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk20d72m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/twrk20d72m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk20d72m.iar/release/bsp/Sources; ../../../../../../lib/twrk20d72m.iar/release; ../../../../../../lib/twrk20d72m.iar/release/bsp; ../../../../../../lib/twrk20d72m.iar/release/psp; ../../../../../../lib/twrk20d72m.iar/release/mfs; ../../../../../../lib/twrk20d72m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk20d72m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk20d72m.iar/release/bsp/bsp.a; ../../../../../../lib/twrk20d72m.iar/release/psp/psp.a; ../../../../../../lib/twrk20d72m.iar/release/mfs/mfs.a; ../../../../../../lib/twrk20d72m.iar/release/shell/shell.a
  group Source
    ../../../: cfcard_file.c cfcard_file.h cfcard_task.c cfcard_task.h shell_task.c shell_task.h tasks.c
