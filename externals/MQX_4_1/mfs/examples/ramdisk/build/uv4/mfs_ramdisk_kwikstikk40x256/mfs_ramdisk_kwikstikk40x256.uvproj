# Keil uVision project mfs_ramdisk_kwikstikk40x256.uvproj, settings and files
target mfs_ramdisk_kwikstikk40x256 Int Flash Debug (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: mfs_ramdisk +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 

 --library_type=standardlib 

--c99

 --diag_suppress=1296,186
  c include: ../../../../../../lib/kwikstikk40x256.uv4/debug/bsp/Generated_Code;../../../../../../lib/kwikstikk40x256.uv4/debug/bsp/Sources;../../../../../../lib/kwikstikk40x256.uv4/debug;../../../../../../lib/kwikstikk40x256.uv4/debug/bsp;../../../../../../lib/kwikstikk40x256.uv4/debug/psp;../../../../../../lib/kwikstikk40x256.uv4/debug/mfs;../../../../../../lib/kwikstikk40x256.uv4/debug/shell
  asm define: _DEBUG=1
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../lib/kwikstikk40x256.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../lib/kwikstikk40x256.uv4/debug/bsp/bsp.lib

../../../../../../lib/kwikstikk40x256.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../lib/kwikstikk40x256.uv4/debug/psp/psp.lib

../../../../../../lib/kwikstikk40x256.uv4/debug/psp/psp.lib(linker_symbols.o)

../../../../../../lib/kwikstikk40x256.uv4/debug/mfs/mfs.lib

../../../../../../lib/kwikstikk40x256.uv4/debug/shell/shell.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
  group Source
    ../../../: tasks.c shell_task.c
target mfs_ramdisk_kwikstikk40x256 Int Flash Release (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: mfs_ramdisk +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../../../../../lib/kwikstikk40x256.uv4/release/bsp/Generated_Code;../../../../../../lib/kwikstikk40x256.uv4/release/bsp/Sources;../../../../../../lib/kwikstikk40x256.uv4/release;../../../../../../lib/kwikstikk40x256.uv4/release/bsp;../../../../../../lib/kwikstikk40x256.uv4/release/psp;../../../../../../lib/kwikstikk40x256.uv4/release/mfs;../../../../../../lib/kwikstikk40x256.uv4/release/shell
  asm misc: --cpreproc 

 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../lib/kwikstikk40x256.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/kwikstikk40x256.uv4/release/bsp/bsp.lib

../../../../../../lib/kwikstikk40x256.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../lib/kwikstikk40x256.uv4/release/psp/psp.lib

../../../../../../lib/kwikstikk40x256.uv4/release/psp/psp.lib(linker_symbols.o)

../../../../../../lib/kwikstikk40x256.uv4/release/mfs/mfs.lib

../../../../../../lib/kwikstikk40x256.uv4/release/shell/shell.lib

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=6314,6329 

 --remove 

 --autoat
