# IAR project mfs_ramdisk_twrk21d50m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21DN512xxx5 Freescale MK21DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../../../../lib/twrk21d50m.iar/debug/bsp/Generated_Code; ../../../../../../lib/twrk21d50m.iar/debug/bsp/Sources; ../../../../../../lib/twrk21d50m.iar/debug; ../../../../../../lib/twrk21d50m.iar/debug/bsp; ../../../../../../lib/twrk21d50m.iar/debug/psp; ../../../../../../lib/twrk21d50m.iar/debug/mfs; ../../../../../../lib/twrk21d50m.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk21d50m.srec
  ILINK.IlinkOutputFile: mfs_ramdisk.out
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk21d50m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk21d50m.iar/debug/bsp/bsp.a; ../../../../../../lib/twrk21d50m.iar/debug/psp/psp.a; ../../../../../../lib/twrk21d50m.iar/debug/mfs/mfs.a; ../../../../../../lib/twrk21d50m.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../../lib/twrk21d50m.iar/release/bsp/Generated_Code; ../../../../../../lib/twrk21d50m.iar/release/bsp/Sources; ../../../../../../lib/twrk21d50m.iar/release; ../../../../../../lib/twrk21d50m.iar/release/bsp; ../../../../../../lib/twrk21d50m.iar/release/psp; ../../../../../../lib/twrk21d50m.iar/release/mfs; ../../../../../../lib/twrk21d50m.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/twrk21d50m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/twrk21d50m.iar/release/bsp/bsp.a; ../../../../../../lib/twrk21d50m.iar/release/psp/psp.a; ../../../../../../lib/twrk21d50m.iar/release/mfs/mfs.a; ../../../../../../lib/twrk21d50m.iar/release/shell/shell.a
  group Source
    ../../../: tasks.c shell_task.c
