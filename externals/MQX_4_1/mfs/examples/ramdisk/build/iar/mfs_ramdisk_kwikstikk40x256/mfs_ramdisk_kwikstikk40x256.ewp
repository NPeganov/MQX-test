# IAR project mfs_ramdisk_kwikstikk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../../../../lib/kwikstikk40x256.iar/debug/bsp/Generated_Code; ../../../../../../lib/kwikstikk40x256.iar/debug/bsp/Sources; ../../../../../../lib/kwikstikk40x256.iar/debug; ../../../../../../lib/kwikstikk40x256.iar/debug/bsp; ../../../../../../lib/kwikstikk40x256.iar/debug/psp; ../../../../../../lib/kwikstikk40x256.iar/debug/mfs; ../../../../../../lib/kwikstikk40x256.iar/debug/shell
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: kwikstikk40x256.srec
  ILINK.IlinkOutputFile: mfs_ramdisk.out
  ILINK.IlinkIcfFile: ../../../../../../lib/kwikstikk40x256.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/kwikstikk40x256.iar/debug/bsp/bsp.a; ../../../../../../lib/kwikstikk40x256.iar/debug/psp/psp.a; ../../../../../../lib/kwikstikk40x256.iar/debug/mfs/mfs.a; ../../../../../../lib/kwikstikk40x256.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../../../lib/kwikstikk40x256.iar/release/bsp/Generated_Code; ../../../../../../lib/kwikstikk40x256.iar/release/bsp/Sources; ../../../../../../lib/kwikstikk40x256.iar/release; ../../../../../../lib/kwikstikk40x256.iar/release/bsp; ../../../../../../lib/kwikstikk40x256.iar/release/psp; ../../../../../../lib/kwikstikk40x256.iar/release/mfs; ../../../../../../lib/kwikstikk40x256.iar/release/shell
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/kwikstikk40x256.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/kwikstikk40x256.iar/release/bsp/bsp.a; ../../../../../../lib/kwikstikk40x256.iar/release/psp/psp.a; ../../../../../../lib/kwikstikk40x256.iar/release/mfs/mfs.a; ../../../../../../lib/kwikstikk40x256.iar/release/shell/shell.a
  group Source
    ../../../: tasks.c shell_task.c
