<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk70f120m/bsp_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../ffs/build/iar/ffs_twrk70f120m/ffs_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk70f120m/mfs_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk70f120m/psp_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk70f120m/rtcs_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk70f120m/shell_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk70f120m/usbd_twrk70f120m.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk70f120m/usbh_twrk70f120m.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk70f120m</project><configuration>Debug</configuration></member><member><project>bsp_twrk70f120m</project><configuration>Release</configuration></member><member><project>ffs_twrk70f120m</project><configuration>Debug</configuration></member><member><project>ffs_twrk70f120m</project><configuration>Release</configuration></member><member><project>mfs_twrk70f120m</project><configuration>Debug</configuration></member><member><project>mfs_twrk70f120m</project><configuration>Release</configuration></member><member><project>psp_twrk70f120m</project><configuration>Debug</configuration></member><member><project>psp_twrk70f120m</project><configuration>Release</configuration></member><member><project>rtcs_twrk70f120m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk70f120m</project><configuration>Release</configuration></member><member><project>shell_twrk70f120m</project><configuration>Debug</configuration></member><member><project>shell_twrk70f120m</project><configuration>Release</configuration></member><member><project>usbd_twrk70f120m</project><configuration>Debug</configuration></member><member><project>usbd_twrk70f120m</project><configuration>Release</configuration></member><member><project>usbh_twrk70f120m</project><configuration>Debug</configuration></member><member><project>usbh_twrk70f120m</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk70f120m</project><configuration>Debug</configuration></member><member><project>ffs_twrk70f120m</project><configuration>Debug</configuration></member><member><project>mfs_twrk70f120m</project><configuration>Debug</configuration></member><member><project>psp_twrk70f120m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk70f120m</project><configuration>Debug</configuration></member><member><project>shell_twrk70f120m</project><configuration>Debug</configuration></member><member><project>usbd_twrk70f120m</project><configuration>Debug</configuration></member><member><project>usbh_twrk70f120m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk70f120m</project><configuration>Release</configuration></member><member><project>ffs_twrk70f120m</project><configuration>Release</configuration></member><member><project>mfs_twrk70f120m</project><configuration>Release</configuration></member><member><project>psp_twrk70f120m</project><configuration>Release</configuration></member><member><project>rtcs_twrk70f120m</project><configuration>Release</configuration></member><member><project>shell_twrk70f120m</project><configuration>Release</configuration></member><member><project>usbd_twrk70f120m</project><configuration>Release</configuration></member><member><project>usbh_twrk70f120m</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>