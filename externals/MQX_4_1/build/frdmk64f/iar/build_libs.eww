<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_frdmk64f/bsp_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_frdmk64f/mfs_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_frdmk64f/psp_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_frdmk64f/rtcs_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_frdmk64f/shell_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_frdmk64f/usbd_frdmk64f.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_frdmk64f/usbh_frdmk64f.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_frdmk64f</project><configuration>Debug</configuration></member><member><project>bsp_frdmk64f</project><configuration>Release</configuration></member><member><project>mfs_frdmk64f</project><configuration>Debug</configuration></member><member><project>mfs_frdmk64f</project><configuration>Release</configuration></member><member><project>psp_frdmk64f</project><configuration>Debug</configuration></member><member><project>psp_frdmk64f</project><configuration>Release</configuration></member><member><project>rtcs_frdmk64f</project><configuration>Debug</configuration></member><member><project>rtcs_frdmk64f</project><configuration>Release</configuration></member><member><project>shell_frdmk64f</project><configuration>Debug</configuration></member><member><project>shell_frdmk64f</project><configuration>Release</configuration></member><member><project>usbd_frdmk64f</project><configuration>Debug</configuration></member><member><project>usbd_frdmk64f</project><configuration>Release</configuration></member><member><project>usbh_frdmk64f</project><configuration>Debug</configuration></member><member><project>usbh_frdmk64f</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_frdmk64f</project><configuration>Debug</configuration></member><member><project>mfs_frdmk64f</project><configuration>Debug</configuration></member><member><project>psp_frdmk64f</project><configuration>Debug</configuration></member><member><project>rtcs_frdmk64f</project><configuration>Debug</configuration></member><member><project>shell_frdmk64f</project><configuration>Debug</configuration></member><member><project>usbd_frdmk64f</project><configuration>Debug</configuration></member><member><project>usbh_frdmk64f</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_frdmk64f</project><configuration>Release</configuration></member><member><project>mfs_frdmk64f</project><configuration>Release</configuration></member><member><project>psp_frdmk64f</project><configuration>Release</configuration></member><member><project>rtcs_frdmk64f</project><configuration>Release</configuration></member><member><project>shell_frdmk64f</project><configuration>Release</configuration></member><member><project>usbd_frdmk64f</project><configuration>Release</configuration></member><member><project>usbh_frdmk64f</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>