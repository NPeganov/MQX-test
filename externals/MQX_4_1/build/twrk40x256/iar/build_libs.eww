<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk40x256/bsp_twrk40x256.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk40x256/mfs_twrk40x256.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk40x256/psp_twrk40x256.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk40x256/rtcs_twrk40x256.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk40x256/shell_twrk40x256.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk40x256/usbd_twrk40x256.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk40x256/usbh_twrk40x256.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk40x256</project><configuration>Debug</configuration></member><member><project>bsp_twrk40x256</project><configuration>Release</configuration></member><member><project>mfs_twrk40x256</project><configuration>Debug</configuration></member><member><project>mfs_twrk40x256</project><configuration>Release</configuration></member><member><project>psp_twrk40x256</project><configuration>Debug</configuration></member><member><project>psp_twrk40x256</project><configuration>Release</configuration></member><member><project>rtcs_twrk40x256</project><configuration>Debug</configuration></member><member><project>rtcs_twrk40x256</project><configuration>Release</configuration></member><member><project>shell_twrk40x256</project><configuration>Debug</configuration></member><member><project>shell_twrk40x256</project><configuration>Release</configuration></member><member><project>usbd_twrk40x256</project><configuration>Debug</configuration></member><member><project>usbd_twrk40x256</project><configuration>Release</configuration></member><member><project>usbh_twrk40x256</project><configuration>Debug</configuration></member><member><project>usbh_twrk40x256</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk40x256</project><configuration>Debug</configuration></member><member><project>mfs_twrk40x256</project><configuration>Debug</configuration></member><member><project>psp_twrk40x256</project><configuration>Debug</configuration></member><member><project>rtcs_twrk40x256</project><configuration>Debug</configuration></member><member><project>shell_twrk40x256</project><configuration>Debug</configuration></member><member><project>usbd_twrk40x256</project><configuration>Debug</configuration></member><member><project>usbh_twrk40x256</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk40x256</project><configuration>Release</configuration></member><member><project>mfs_twrk40x256</project><configuration>Release</configuration></member><member><project>psp_twrk40x256</project><configuration>Release</configuration></member><member><project>rtcs_twrk40x256</project><configuration>Release</configuration></member><member><project>shell_twrk40x256</project><configuration>Release</configuration></member><member><project>usbd_twrk40x256</project><configuration>Release</configuration></member><member><project>usbh_twrk40x256</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>