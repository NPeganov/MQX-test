<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk40d100m/bsp_twrk40d100m.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk40d100m/mfs_twrk40d100m.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk40d100m/psp_twrk40d100m.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk40d100m/rtcs_twrk40d100m.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk40d100m/shell_twrk40d100m.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk40d100m/usbd_twrk40d100m.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk40d100m/usbh_twrk40d100m.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk40d100m</project><configuration>Debug</configuration></member><member><project>bsp_twrk40d100m</project><configuration>Release</configuration></member><member><project>mfs_twrk40d100m</project><configuration>Debug</configuration></member><member><project>mfs_twrk40d100m</project><configuration>Release</configuration></member><member><project>psp_twrk40d100m</project><configuration>Debug</configuration></member><member><project>psp_twrk40d100m</project><configuration>Release</configuration></member><member><project>rtcs_twrk40d100m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk40d100m</project><configuration>Release</configuration></member><member><project>shell_twrk40d100m</project><configuration>Debug</configuration></member><member><project>shell_twrk40d100m</project><configuration>Release</configuration></member><member><project>usbd_twrk40d100m</project><configuration>Debug</configuration></member><member><project>usbd_twrk40d100m</project><configuration>Release</configuration></member><member><project>usbh_twrk40d100m</project><configuration>Debug</configuration></member><member><project>usbh_twrk40d100m</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk40d100m</project><configuration>Debug</configuration></member><member><project>mfs_twrk40d100m</project><configuration>Debug</configuration></member><member><project>psp_twrk40d100m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk40d100m</project><configuration>Debug</configuration></member><member><project>shell_twrk40d100m</project><configuration>Debug</configuration></member><member><project>usbd_twrk40d100m</project><configuration>Debug</configuration></member><member><project>usbh_twrk40d100m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk40d100m</project><configuration>Release</configuration></member><member><project>mfs_twrk40d100m</project><configuration>Release</configuration></member><member><project>psp_twrk40d100m</project><configuration>Release</configuration></member><member><project>rtcs_twrk40d100m</project><configuration>Release</configuration></member><member><project>shell_twrk40d100m</project><configuration>Release</configuration></member><member><project>usbd_twrk40d100m</project><configuration>Release</configuration></member><member><project>usbh_twrk40d100m</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>