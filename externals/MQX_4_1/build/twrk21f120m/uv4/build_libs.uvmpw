<?xml version="1.0" standalone="no"?><ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd"><SchemaVersion>1.0</SchemaVersion><Header>### uVision Project, (C) Keil Software</Header><WorkspaceName>WorkSpace</WorkspaceName><project><PathAndName>..\..\..\mqx\build\uv4\bsp_twrk21f120m\bsp_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project><project><PathAndName>..\..\..\mfs\build\uv4\mfs_twrk21f120m\mfs_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project><project><PathAndName>..\..\..\mqx\build\uv4\psp_twrk21f120m\psp_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project><project><PathAndName>..\..\..\rtcs\build\uv4\rtcs_twrk21f120m\rtcs_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project><project><PathAndName>..\..\..\shell\build\uv4\shell_twrk21f120m\shell_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project><project><PathAndName>..\..\..\usb\device\build\uv4\usbd_twrk21f120m\usbd_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project><project><PathAndName>..\..\..\usb\host\build\uv4\usbh_twrk21f120m\usbh_twrk21f120m.uvproj</PathAndName><NodeIsCheckedInBatchBuild>1</NodeIsCheckedInBatchBuild></project></ProjectWorkspace>