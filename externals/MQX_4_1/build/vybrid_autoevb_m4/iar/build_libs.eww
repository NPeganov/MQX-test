<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_vybrid_autoevb_m4/bsp_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../mcc/build/iar/mcc_vybrid_autoevb_m4/mcc_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_vybrid_autoevb_m4/mfs_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_vybrid_autoevb_m4/psp_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_vybrid_autoevb_m4/rtcs_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_vybrid_autoevb_m4/shell_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_vybrid_autoevb_m4/usbd_vybrid_autoevb_m4.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_vybrid_autoevb_m4/usbh_vybrid_autoevb_m4.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>bsp_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>mcc_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>mcc_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>mfs_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>mfs_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>psp_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>psp_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>rtcs_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>rtcs_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>shell_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>shell_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>usbd_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>usbd_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>usbh_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>usbh_vybrid_autoevb_m4</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>mcc_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>mfs_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>psp_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>rtcs_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>shell_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>usbd_vybrid_autoevb_m4</project><configuration>Debug</configuration></member><member><project>usbh_vybrid_autoevb_m4</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>mcc_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>mfs_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>psp_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>rtcs_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>shell_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>usbd_vybrid_autoevb_m4</project><configuration>Release</configuration></member><member><project>usbh_vybrid_autoevb_m4</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>