<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrvf65gs10_m4/bsp_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../ffs/build/iar/ffs_twrvf65gs10_m4/ffs_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../mcc/build/iar/mcc_twrvf65gs10_m4/mcc_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrvf65gs10_m4/mfs_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrvf65gs10_m4/psp_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrvf65gs10_m4/rtcs_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrvf65gs10_m4/shell_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrvf65gs10_m4/usbd_twrvf65gs10_m4.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrvf65gs10_m4/usbh_twrvf65gs10_m4.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>bsp_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>ffs_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>ffs_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>mcc_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>mcc_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>mfs_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>mfs_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>psp_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>psp_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>rtcs_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>rtcs_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>shell_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>shell_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>usbd_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>usbd_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>usbh_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>usbh_twrvf65gs10_m4</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>ffs_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>mcc_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>mfs_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>psp_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>rtcs_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>shell_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>usbd_twrvf65gs10_m4</project><configuration>Debug</configuration></member><member><project>usbh_twrvf65gs10_m4</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>ffs_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>mcc_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>mfs_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>psp_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>rtcs_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>shell_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>usbd_twrvf65gs10_m4</project><configuration>Release</configuration></member><member><project>usbh_twrvf65gs10_m4</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>