<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_kwikstikk40x256/bsp_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_kwikstikk40x256/mfs_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_kwikstikk40x256/psp_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_kwikstikk40x256/rtcs_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_kwikstikk40x256/shell_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_kwikstikk40x256/usbd_kwikstikk40x256.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_kwikstikk40x256/usbh_kwikstikk40x256.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>bsp_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>mfs_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>mfs_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>psp_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>psp_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>rtcs_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>rtcs_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>shell_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>shell_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>usbd_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>usbd_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>usbh_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>usbh_kwikstikk40x256</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>mfs_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>psp_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>rtcs_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>shell_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>usbd_kwikstikk40x256</project><configuration>Debug</configuration></member><member><project>usbh_kwikstikk40x256</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>mfs_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>psp_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>rtcs_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>shell_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>usbd_kwikstikk40x256</project><configuration>Release</configuration></member><member><project>usbh_kwikstikk40x256</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>