<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk53n512/bsp_twrk53n512.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk53n512/mfs_twrk53n512.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk53n512/psp_twrk53n512.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk53n512/rtcs_twrk53n512.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk53n512/shell_twrk53n512.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk53n512/usbd_twrk53n512.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk53n512/usbh_twrk53n512.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk53n512</project><configuration>Debug</configuration></member><member><project>bsp_twrk53n512</project><configuration>Release</configuration></member><member><project>mfs_twrk53n512</project><configuration>Debug</configuration></member><member><project>mfs_twrk53n512</project><configuration>Release</configuration></member><member><project>psp_twrk53n512</project><configuration>Debug</configuration></member><member><project>psp_twrk53n512</project><configuration>Release</configuration></member><member><project>rtcs_twrk53n512</project><configuration>Debug</configuration></member><member><project>rtcs_twrk53n512</project><configuration>Release</configuration></member><member><project>shell_twrk53n512</project><configuration>Debug</configuration></member><member><project>shell_twrk53n512</project><configuration>Release</configuration></member><member><project>usbd_twrk53n512</project><configuration>Debug</configuration></member><member><project>usbd_twrk53n512</project><configuration>Release</configuration></member><member><project>usbh_twrk53n512</project><configuration>Debug</configuration></member><member><project>usbh_twrk53n512</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk53n512</project><configuration>Debug</configuration></member><member><project>mfs_twrk53n512</project><configuration>Debug</configuration></member><member><project>psp_twrk53n512</project><configuration>Debug</configuration></member><member><project>rtcs_twrk53n512</project><configuration>Debug</configuration></member><member><project>shell_twrk53n512</project><configuration>Debug</configuration></member><member><project>usbd_twrk53n512</project><configuration>Debug</configuration></member><member><project>usbh_twrk53n512</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk53n512</project><configuration>Release</configuration></member><member><project>mfs_twrk53n512</project><configuration>Release</configuration></member><member><project>psp_twrk53n512</project><configuration>Release</configuration></member><member><project>rtcs_twrk53n512</project><configuration>Release</configuration></member><member><project>shell_twrk53n512</project><configuration>Release</configuration></member><member><project>usbd_twrk53n512</project><configuration>Release</configuration></member><member><project>usbh_twrk53n512</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>