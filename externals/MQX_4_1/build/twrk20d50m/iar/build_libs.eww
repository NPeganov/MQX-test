<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk20d50m/bsp_twrk20d50m.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk20d50m/mfs_twrk20d50m.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk20d50m/psp_twrk20d50m.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk20d50m/rtcs_twrk20d50m.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk20d50m/shell_twrk20d50m.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk20d50m/usbd_twrk20d50m.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk20d50m/usbh_twrk20d50m.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk20d50m</project><configuration>Debug</configuration></member><member><project>bsp_twrk20d50m</project><configuration>Release</configuration></member><member><project>mfs_twrk20d50m</project><configuration>Debug</configuration></member><member><project>mfs_twrk20d50m</project><configuration>Release</configuration></member><member><project>psp_twrk20d50m</project><configuration>Debug</configuration></member><member><project>psp_twrk20d50m</project><configuration>Release</configuration></member><member><project>rtcs_twrk20d50m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk20d50m</project><configuration>Release</configuration></member><member><project>shell_twrk20d50m</project><configuration>Debug</configuration></member><member><project>shell_twrk20d50m</project><configuration>Release</configuration></member><member><project>usbd_twrk20d50m</project><configuration>Debug</configuration></member><member><project>usbd_twrk20d50m</project><configuration>Release</configuration></member><member><project>usbh_twrk20d50m</project><configuration>Debug</configuration></member><member><project>usbh_twrk20d50m</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk20d50m</project><configuration>Debug</configuration></member><member><project>mfs_twrk20d50m</project><configuration>Debug</configuration></member><member><project>psp_twrk20d50m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk20d50m</project><configuration>Debug</configuration></member><member><project>shell_twrk20d50m</project><configuration>Debug</configuration></member><member><project>usbd_twrk20d50m</project><configuration>Debug</configuration></member><member><project>usbh_twrk20d50m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk20d50m</project><configuration>Release</configuration></member><member><project>mfs_twrk20d50m</project><configuration>Release</configuration></member><member><project>psp_twrk20d50m</project><configuration>Release</configuration></member><member><project>rtcs_twrk20d50m</project><configuration>Release</configuration></member><member><project>shell_twrk20d50m</project><configuration>Release</configuration></member><member><project>usbd_twrk20d50m</project><configuration>Release</configuration></member><member><project>usbh_twrk20d50m</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>