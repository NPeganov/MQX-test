<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk21d50m/bsp_twrk21d50m.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk21d50m/mfs_twrk21d50m.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk21d50m/psp_twrk21d50m.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk21d50m/rtcs_twrk21d50m.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk21d50m/shell_twrk21d50m.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk21d50m/usbd_twrk21d50m.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk21d50m/usbh_twrk21d50m.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk21d50m</project><configuration>Debug</configuration></member><member><project>bsp_twrk21d50m</project><configuration>Release</configuration></member><member><project>mfs_twrk21d50m</project><configuration>Debug</configuration></member><member><project>mfs_twrk21d50m</project><configuration>Release</configuration></member><member><project>psp_twrk21d50m</project><configuration>Debug</configuration></member><member><project>psp_twrk21d50m</project><configuration>Release</configuration></member><member><project>rtcs_twrk21d50m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk21d50m</project><configuration>Release</configuration></member><member><project>shell_twrk21d50m</project><configuration>Debug</configuration></member><member><project>shell_twrk21d50m</project><configuration>Release</configuration></member><member><project>usbd_twrk21d50m</project><configuration>Debug</configuration></member><member><project>usbd_twrk21d50m</project><configuration>Release</configuration></member><member><project>usbh_twrk21d50m</project><configuration>Debug</configuration></member><member><project>usbh_twrk21d50m</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk21d50m</project><configuration>Debug</configuration></member><member><project>mfs_twrk21d50m</project><configuration>Debug</configuration></member><member><project>psp_twrk21d50m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk21d50m</project><configuration>Debug</configuration></member><member><project>shell_twrk21d50m</project><configuration>Debug</configuration></member><member><project>usbd_twrk21d50m</project><configuration>Debug</configuration></member><member><project>usbh_twrk21d50m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk21d50m</project><configuration>Release</configuration></member><member><project>mfs_twrk21d50m</project><configuration>Release</configuration></member><member><project>psp_twrk21d50m</project><configuration>Release</configuration></member><member><project>rtcs_twrk21d50m</project><configuration>Release</configuration></member><member><project>shell_twrk21d50m</project><configuration>Release</configuration></member><member><project>usbd_twrk21d50m</project><configuration>Release</configuration></member><member><project>usbh_twrk21d50m</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>