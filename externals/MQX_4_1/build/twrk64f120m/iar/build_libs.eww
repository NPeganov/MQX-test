<workspace><project><path>$WS_DIR$/../../../mqx/build/iar/bsp_twrk64f120m/bsp_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../mfs/build/iar/mfs_twrk64f120m/mfs_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../mqx/build/iar/psp_twrk64f120m/psp_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../rtcs/build/iar/rtcs_twrk64f120m/rtcs_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../shell/build/iar/shell_twrk64f120m/shell_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../usb/device/build/iar/usbd_twrk64f120m/usbd_twrk64f120m.ewp</path></project><project><path>$WS_DIR$/../../../usb/host/build/iar/usbh_twrk64f120m/usbh_twrk64f120m.ewp</path></project><batchBuild><batchDefinition><name>Build All</name><member><project>bsp_twrk64f120m</project><configuration>Debug</configuration></member><member><project>bsp_twrk64f120m</project><configuration>Release</configuration></member><member><project>mfs_twrk64f120m</project><configuration>Debug</configuration></member><member><project>mfs_twrk64f120m</project><configuration>Release</configuration></member><member><project>psp_twrk64f120m</project><configuration>Debug</configuration></member><member><project>psp_twrk64f120m</project><configuration>Release</configuration></member><member><project>rtcs_twrk64f120m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk64f120m</project><configuration>Release</configuration></member><member><project>shell_twrk64f120m</project><configuration>Debug</configuration></member><member><project>shell_twrk64f120m</project><configuration>Release</configuration></member><member><project>usbd_twrk64f120m</project><configuration>Debug</configuration></member><member><project>usbd_twrk64f120m</project><configuration>Release</configuration></member><member><project>usbh_twrk64f120m</project><configuration>Debug</configuration></member><member><project>usbh_twrk64f120m</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>bsp_twrk64f120m</project><configuration>Debug</configuration></member><member><project>mfs_twrk64f120m</project><configuration>Debug</configuration></member><member><project>psp_twrk64f120m</project><configuration>Debug</configuration></member><member><project>rtcs_twrk64f120m</project><configuration>Debug</configuration></member><member><project>shell_twrk64f120m</project><configuration>Debug</configuration></member><member><project>usbd_twrk64f120m</project><configuration>Debug</configuration></member><member><project>usbh_twrk64f120m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>bsp_twrk64f120m</project><configuration>Release</configuration></member><member><project>mfs_twrk64f120m</project><configuration>Release</configuration></member><member><project>psp_twrk64f120m</project><configuration>Release</configuration></member><member><project>rtcs_twrk64f120m</project><configuration>Release</configuration></member><member><project>shell_twrk64f120m</project><configuration>Release</configuration></member><member><project>usbd_twrk64f120m</project><configuration>Release</configuration></member><member><project>usbh_twrk64f120m</project><configuration>Release</configuration></member></batchDefinition></batchBuild></workspace>