# IAR project pingpong_example_vybrid_autoevb_a5.ewp, settings and files
configuration DDR Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/vybrid_autoevb_a5.iar/debug; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp/Generated_Code; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/psp; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/mcc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: vybrid_autoevb_a5.bin
  ILINK.IlinkOutputFile: pingpong_example.out
  ILINK.IlinkIcfFile: ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/vybrid_autoevb_a5.iar/debug/bsp/bsp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/psp/psp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/debug/mcc/mcc.a
  ILINK.IlinkProgramEntryLabel: __boot
configuration DDR Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: ../../..; ../../../../../../lib/vybrid_autoevb_a5.iar/release; ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp; ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp/Generated_Code; ../../../../../../lib/vybrid_autoevb_a5.iar/release/psp; ../../../../../../lib/vybrid_autoevb_a5.iar/release/mcc
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp/ddr.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../lib/vybrid_autoevb_a5.iar/release/bsp/bsp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/release/psp/psp.a; ../../../../../../lib/vybrid_autoevb_a5.iar/release/mcc/mcc.a
  group Source
    ../../../: mcc.c mcc.h
